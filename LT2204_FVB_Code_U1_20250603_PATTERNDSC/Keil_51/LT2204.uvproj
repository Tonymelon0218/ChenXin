# Keil uVision project LT2204.uvproj, settings and files
target Target 1 (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: LT6911GXD_Pattern_MIPI_3D_NoBurst_4320x2160@90_25111103 +hex
  c flags: Optimize=12
  c include: ..\User\L0_App;..\User\L1_Module;..\User\L2_Drive;..\User\L3_Ocm
  link misc: REMOVEUNUSED
  group Startup
    ../Startup/: STARTUP.A51
  group L0_App
    ../User/L0_App/: main.c LT7911GXE.c
    ./Objects/: LT6911GXD_PATTERN_DSC.LIB
  group L1_Module
    ../User/L1_Module/: Interrupt.c ModDpRx.c ModMipiTx.c ModSystem.c ModMipiDscEncTx.c ModDCS.c
  group L2_Drive
    ../User/L2_Drive/: Register.c
  group L3_Ocm
    ../User/L3_Ocm/: OcmPrint.c OcmTimer.c FwVersion.asm
  group L4_Log
    ./: DebuggingLOG.txt
